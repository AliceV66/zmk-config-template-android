## boards/shields/wired_split_funda/Kconfig.shield
```kconfig
# Define un booleano para tu shield
config SHIELD_WIRED_SPLIT_FUNDA
    def_bool y
```
